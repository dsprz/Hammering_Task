Commit message: Added modiied file + nail.xml

File: addFiles/HRP5Pmain.urdf (robot description, URDF)
Before this commit: robot HRP5P, 70 links, 69 joints
Joints:
- joint hammer_head: origin xyz=0.17 0.01 0.21 rpy=1.57 0.0 0.0 -> xyz=0.118 -0.02 0.21 rpy=1.57 0 -1.57
